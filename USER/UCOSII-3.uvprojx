# Keil uVision project UCOSII-3.uvprojx, settings and files
target UCOSII-3 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: UCOSII-3 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\BEEP;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\TPAD;..\MALLOC;..\HARDWARE\UKF_BARO;..\HARDWARE\EKF_BARO;..\HARDWARE\SYS_IDENT;..\HARDWARE\AVOID
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
    ../HARDWARE/: parameter.c ucos_task.c datasheet.txt include.h
  group SYSTEM
    ../CORE/: startup_stm32f40_41xxx.s
    ../UCOSII/CONFIG/: os_cfg.h
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_adc.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group HARDWARE
    ../HARDWARE/DRIVER/: flash.c iic.c dma.c pwm_out.c time.c iic1.c
    ../HARDWARE/: error.c
  group COMMUNICATION
    ../HARDWARE/DRIVER/: rc_mine.c usart_fc.c
  group MEMS
    ../HARDWARE/MEMS/: hml_sample.c mpu6050.c ms5611_2.c ultrasonic.c
  group CONTROL
    ../HARDWARE/CONTROL/: att_control.c eso.c h_inf.c height_ctrl.c neuron_pid.c visual_contol.c
  group MATH&MATRIX
    ../DSP_LIB/: arm_cortexM4lf_math.lib
    ../HARDWARE/MATH/: FastMath.c Matrix.c miniMatrix.c my_math.c Quaternion.c
  group FUSHION
    ../HARDWARE/UKF_BARO/: kf_oldx.lib
    ../HARDWARE/EKF_BARO/: baro_ekf_oldx.lib
    ../HARDWARE/FUSHION/: imu1.c alt_kf.c kf_oldx_yaw.lib
  group SYS_IDENT
    ../HARDWARE/SYS_IDENT/: CFFRELS.c LibMatrix.c LibMyMath.c PPCFFRELS.c RELS.c ident.c STC_PP.c STC_PP_PID.c ControlFGR.c
  group AVOID
    ../HARDWARE/CONTROL/: sonar_avoid.c
    ../HARDWARE/AVOID/: F407_FC_8.lib
